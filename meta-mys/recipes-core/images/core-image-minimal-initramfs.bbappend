INITRAMFS_SCRIPTS = "\
    initramfs-framework-base \
    initramfs-module-setup-live \
    initramfs-module-udev \
    "
